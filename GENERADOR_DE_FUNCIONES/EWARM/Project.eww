<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GENERADOR_DE_FUNCIONES.ewp</path>
  </project>
  <batchBuild />
</workspace>
